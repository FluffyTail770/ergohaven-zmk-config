## config/west.yml
```yaml
manifest:
  defaults:
    remote: ergohaven
  projects:
    - name: ergohaven-zmk
      revision: main
      import: app/west.yml
  shields:
    - op-36
```
